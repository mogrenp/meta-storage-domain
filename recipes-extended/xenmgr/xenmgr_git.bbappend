FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://add-manager-support.patch \
"
