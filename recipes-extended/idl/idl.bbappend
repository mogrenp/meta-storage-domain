FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://add-disk-backend-properties.patch \
"
