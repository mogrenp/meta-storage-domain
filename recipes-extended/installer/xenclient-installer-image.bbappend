FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://files/extra-hard-drive-space.patch \
"
